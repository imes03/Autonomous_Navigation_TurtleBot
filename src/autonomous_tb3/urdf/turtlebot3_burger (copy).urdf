Commit message: Added april tag and RRT

File: src/autonomous_tb3/urdf/turtlebot3_burger (copy).urdf (robot description, URDF)
Before this commit: robot turtlebot3_burger, 8 links, 7 joints
Links:
- removed link ${namespace}camera_link
Joints:
- removed joint ${namespace}camera_joint
